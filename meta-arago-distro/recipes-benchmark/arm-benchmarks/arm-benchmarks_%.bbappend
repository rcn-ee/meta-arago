PR_append = ".arago0"

SRCIPK_SRC_DIR = "${S}/${PLATFORM_ARCH}"
