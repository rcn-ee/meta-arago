PR_append = ".arago0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DEPENDS_remove = "virtual/libgl"
