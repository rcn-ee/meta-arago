PR:append = ".arago0"

# look for files in this layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
