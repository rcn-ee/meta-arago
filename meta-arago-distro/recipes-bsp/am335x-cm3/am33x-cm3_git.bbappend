PR_append = "-arago0"

PV = "05.06.00.00"

BRANCH = "master"

#This SRCREV corresponds to tag AM335xPSP_04.06.00.09-rc
SRCREV = "7c6075f28d9fdd633175cdbd8dc287613ce92e5d"

SRC_URI = "git://arago-project.org/git/projects/am33x-cm3.git;protocol=git;branch=${BRANCH}"
