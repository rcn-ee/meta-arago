DEPENDS += "doxygen-native"
