PR_append = ".arago0"

SRCIPK_SRC_DIR = "${WORKDIR}/git/ti/runtime/hplib"
