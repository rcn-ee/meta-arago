PR_append = "-arago0"

# PSPREL and UVER are used by arago-source-ipk.conf
PSPREL = "05.06.00.00"
UVER = "2012.10"
