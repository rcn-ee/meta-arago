PR_append = "-arago0"

# PSPREL and UVER are used by arago-source-ipk.conf
PSPREL = "05.07.00.00"
UVER = "2013.01.01"
