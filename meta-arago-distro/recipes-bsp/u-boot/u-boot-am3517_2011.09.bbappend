PR_append = "-arago0"

# PSPREL and UVER are used by arago-source-ipk.conf
PSPREL = "04.06.00.08"
UVER = "2011.09"
