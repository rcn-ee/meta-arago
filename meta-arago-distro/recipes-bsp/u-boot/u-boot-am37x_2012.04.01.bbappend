PR_append = "-arago0"

UVER = "2012.04.01"
PSPREL = "mainline"
