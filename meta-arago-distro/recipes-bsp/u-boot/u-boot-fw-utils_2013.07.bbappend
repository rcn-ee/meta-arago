PR_append = "-arago0+gitr${SRCPV}"

# The proper config doesn't currently exist anywhere in mainline U-boot.
# For now just use a similar config which is good enough for U-boot utilities.
UBOOT_MACHINE_am57xx-evm = "dra7xx_evm_config"

