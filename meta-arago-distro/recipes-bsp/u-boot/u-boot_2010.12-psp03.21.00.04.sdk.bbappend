PR_append = "-arago0"

# PSPREL and UVER are used by arago-source-ipk.conf
UVER = "2010.12"
PSPREL = "03.21.00.04.sdk"
