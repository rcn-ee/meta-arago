# Append the base 2014.07 u-boot mainline recipe to AUTOREV for now so that
# we can test the latest mainline

PR_append = "-arago1+gitr${SRCPV}"

SRCREV = "${AUTOREV}"
