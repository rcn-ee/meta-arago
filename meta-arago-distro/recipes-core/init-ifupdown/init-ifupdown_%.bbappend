# look for files in this layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PR:append = ".arago1"
