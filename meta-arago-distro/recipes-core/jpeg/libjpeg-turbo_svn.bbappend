python __anonymous () {
    d.setVar("SRC_URI", d.getVar("SRC_URI").replace("protocol=svn", "protocol=http"))
}
