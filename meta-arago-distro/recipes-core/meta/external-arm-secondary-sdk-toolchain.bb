TARGET_ARCH := "${SECONDARY_TARGET_ARCH}"
MACHINEOVERRIDES := "${SECONDARY_TARGET_ARCH}"

require recipes-core/meta/external-arm-sdk-toolchain.bb
