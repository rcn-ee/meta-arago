TARGET_ARCH := "${SECONDARY_TARGET_ARCH}"
MACHINEOVERRIDES := "${SECONDARY_TARGET_ARCH}"

require recipes-core/meta/external-linaro-sdk-toolchain.bb
