FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

FILES_${PN}-doc += "${datadir}/cmake-${CMAKE_MAJOR_VERSION}/Help/"
