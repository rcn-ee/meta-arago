require gcc-linaro-common-4.7.inc
require gcc_${BASEPV}.bb

DEPENDS =+ "gmp-native"
