require gcc-linaro-common-5.3.inc
require gcc-linaro-5.3.inc
require recipes-devtools/gcc/libgcc-initial.inc
