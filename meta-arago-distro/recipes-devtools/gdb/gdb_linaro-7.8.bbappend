PR_append = ".arago0"

PACKAGECONFIG[python] = "--with-python=${WORKDIR}/python,--without-python,python,python-modules"
