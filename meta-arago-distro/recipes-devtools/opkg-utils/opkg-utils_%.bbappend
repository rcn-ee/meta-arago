FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-opkg-build-re-do-find-ls-code-to-not-fail-on-filenam.patch \
"
