LIC_FILES_CHKSUM = "file://LICENSE;md5=beb87117af69fd10fbf9fb14c22a2e62"
S = "${WORKDIR}/git"
SRC_URI = "git://github.com/pybind/pybind11.git"
SRCREV = "086d53e8c66a84d0ec723d5435918c76edd878e8"
PV = "2.2.2+2.2.1-git"
