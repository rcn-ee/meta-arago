READELF_class-target = "arm-linux-gnueabihf-readelf"
export READELF
