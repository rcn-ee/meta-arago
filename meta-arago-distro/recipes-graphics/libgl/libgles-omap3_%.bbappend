RRECOMMENDS_${PN}_remove = "omap3-sgx-modules"
