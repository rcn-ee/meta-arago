# look for files in this layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PR:append = ".arago1"
