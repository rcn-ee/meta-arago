PR_append = "-arago3"

# KVER is used by arago-source-ipk.conf
KVER = "${PV}"

require copy-defconfig.inc
