MACHINE_KERNEL_PR_append = "-arago1"

# KVER is used by arago-source-ipk.conf
KVER = "2.6.37"
PSPREL = "04.02.00.07"

require copy-defconfig.inc
