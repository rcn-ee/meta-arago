PR_append = "-arago0"

require copy-defconfig.inc
require setup-defconfig.inc
