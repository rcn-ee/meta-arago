PR_append = "-arago0"

PACKAGE_ARCH = "${MACHINE_ARCH}"
