PR_append = "-arago0"

# Select the non GPLv3 license option for distribution of this plugin with our
# SDK
LICENSE = "GPLv2+ & LGPLv2+ & (GPLv2+ & LGPLv2.1+)"
