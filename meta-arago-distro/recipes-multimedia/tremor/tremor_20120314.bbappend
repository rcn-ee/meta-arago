PR_append = "-arago0"

EXTRA_OEMAKE += "-mimplicit-it=thumb"
