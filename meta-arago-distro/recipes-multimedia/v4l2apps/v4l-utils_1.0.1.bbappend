SRC_URI = "git://linuxtv.org/v4l-utils.git"

SRCREV = "3719cef229379f1f2cb2fe61f2359bdac6cff6b0"

S = "${WORKDIR}/git"

PR_append = "-arago0"
