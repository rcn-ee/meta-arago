require arago-qt4.inc

PR := "${PR}.0"
