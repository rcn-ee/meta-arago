FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-qquickviewcomparison-fix-QCoreApplication-has-not-be.patch \
"
