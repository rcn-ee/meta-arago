
PR_append = ".arago0"

PV = "3.12.0+git${SRCPV}"

SRCREV = "347144b79964233e718347e3f0fbe89ab5be46ae"

