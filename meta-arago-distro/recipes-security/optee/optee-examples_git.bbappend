
PR_append = ".arago0"

PV = "3.12.0+git${SRCPV}"

SRCREV = "9a755dcf4d8ef6117af59dfd1b1a82315cee58ca"

