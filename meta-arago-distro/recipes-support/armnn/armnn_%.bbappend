inherit machine_features_check

REQUIRED_MACHINE_FEATURES = "dsp"
