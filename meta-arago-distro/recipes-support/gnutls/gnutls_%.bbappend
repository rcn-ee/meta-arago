PR_append = ".arago0"

# Set INCOMPATIBLE_LICENSE to GPLv3 to allow gnutls to use the non GPLv2
# version of gettext.
INCOMPATIBLE_LICENSE = "GPLv3"
