CFLAGS += "-fcommon"
