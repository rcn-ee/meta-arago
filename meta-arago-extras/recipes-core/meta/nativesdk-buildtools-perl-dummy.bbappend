DUMMYPROVIDES += "\
    nativesdk-perl-module-file-spec-unix \
    nativesdk-perl-module-symbol \
"
