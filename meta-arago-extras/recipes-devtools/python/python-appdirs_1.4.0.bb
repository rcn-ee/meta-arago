SUMMARY = "A small Python module for determining appropriate + platform-specific dirs, e.g. a "user data dir"."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=31625363c45eb0c67c630a2f73e438e4"

SRC_URI[md5sum] = "1d17b4c9694ab84794e228f28dc3275b"
SRC_URI[sha256sum] = "8fc245efb4387a4e3e0ac8ebcc704582df7d72ff6a42a53f5600bbb18fdaadc5"

inherit pypi setuptools
