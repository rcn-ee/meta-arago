PR_append = "-arago0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
