PR_append = "-arago0"

QT_MODULE_BRANCH = "5.3"
